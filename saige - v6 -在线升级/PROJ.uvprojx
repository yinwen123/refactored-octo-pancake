# Keil uVision project PROJ.uvprojx, settings and files
target CW32F003 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CW32F003F4 WHXY
  pack: WHXY.CW32F003_DFP.1.0.4
  cpu: IRAM(0x20000000,0x00C00) IROM(0x00000000,0x05000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PORJ +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: OneElfS=1 uC99=1 wLevel=2
  c include: .\Inc;.\Core
  library: MicroLIB
  memory RVCT4: ROM 0x800 size 0x4fe0
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Src
    ./Src/: adc.c flash.c main.c port.c tim.c com.c fdq.c key.c led.c music.c rf.c nfc522.c cw32f003_gpio.c cw32f003_uart.c
    ./: USART485.c
  group Inc
    ./Inc/: adc.h flash.h inc.h port.h tim.h type.h com.h fdq.h key.h led.h music.h rf.h
  group Core
    ./Core/: startup_cw32f003.s
software components: CMSIS:CORE 5.6.0
